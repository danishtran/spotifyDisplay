FILESEXTRAPATHS:prepend := "${THISDIR}:"

SRC_URI += "file://spi.txt"
